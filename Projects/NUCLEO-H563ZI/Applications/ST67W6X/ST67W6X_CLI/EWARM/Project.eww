<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ST67W6X_CLI.ewp</path>
  </project>
  <batchBuild />
</workspace>
