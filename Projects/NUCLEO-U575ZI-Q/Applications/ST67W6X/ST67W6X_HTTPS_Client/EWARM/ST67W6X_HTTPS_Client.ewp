# IAR project ST67W6X_HTTPS_Client.ewp, settings and files
configuration ST67W6X_HTTPS_Client (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: configTASK_NOTIFICATION_ARRAY_ENTRIES=8; LFS_CONFIG=lfs_util_config.h; USE_HAL_DRIVER; STM32U575xx
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../Core/Inc; ../App_HTTPS_Client/App; ../App_HTTPS_Client/Target; ../ST67W6X/Target; ../littlefs/Target; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include/; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../../../../../../Drivers/CMSIS/RTOS2/Include/; ../../../../../../Middlewares/Third_Party/cJSON; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_at; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_bus; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Api; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Shell; ../../../../../../Middlewares/Third_Party/littlefs
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: configTASK_NOTIFICATION_ARRAY_ENTRIES=8
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ST67W6X_HTTPS_Client.bin
  ILINK.IlinkOutputFile: ST67W6X_HTTPS_Client.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/User/App_HTTPS_Client/App
    ../App_HTTPS_Client/App/: https_client.c main_app.c
  group Application/User/App_HTTPS_Client/Target
    ../App_HTTPS_Client/Target/: freertos_tickless.c logshell_ctrl.c stm32_lpm_if.c
  group Application/User/Core
    ../Core/Src/: app_freertos.c main.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c stm32u5xx_it.c
  group Application/User/littlefs/Target
    ../littlefs/Target/: lfs_easyflash.c lfs_flash.c
  group Application/User/ST67W6X/Target
    ../ST67W6X/Target/: spi_port.c
  group Doc
    ../: readme.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_lptim.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middlewares/cJSON/Data Exchange/cJSON
    ../../../../../../Middlewares/Third_Party/cJSON/: cJSON.c
  group Middlewares/LittleFS/File System/LittleFS
    ../../../../../../Middlewares/Third_Party/littlefs/: lfs.c lfs_util.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Supported
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/ST67W6X_Network_Driver/Network/Driver/W61_at_and_bus
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Misc/: common_parser.c
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_bus/: spi_iface.c w61_io.c
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_at/: w61_at_ble.c w61_at_common.c w61_at_mqtt.c w61_at_net.c w61_at_rx_parser.c w61_at_sys.c w61_at_wifi.c
  group Middlewares/ST67W6X_Network_Driver/Network/ServiceAPI
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core/: w6x_ble.c w6x_http.c w6x_mqtt.c w6x_net.c w6x_ota.c w6x_sys.c w6x_wifi.c
  group Middlewares/ST67W6X_Network_Driver/Network/ServiceShell
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core/: w6x_ble_shell.c w6x_mqtt_shell.c w6x_net_shell.c w6x_sys_shell.c w6x_wifi_shell.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Logging
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Logging/: logging.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Shell
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Shell/: shell.c shell_freertos.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
