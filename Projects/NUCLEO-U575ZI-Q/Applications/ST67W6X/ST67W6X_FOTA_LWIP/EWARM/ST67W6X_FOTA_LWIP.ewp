# IAR project ST67W6X_FOTA_LWIP.ewp, settings and files
configuration ST67W6X_FOTA_LWIP (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: configTASK_NOTIFICATION_ARRAY_ENTRIES=8; ST67_ARCH=W6X_ARCH_T02; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; USE_HAL_DRIVER; STM32U575xx
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../Core/Inc; ../ST67W6X/App; ../Appli/App; ../Appli/Target; ../ST67W6X/Target; ../LWIP/App; ../LWIP/Target; ../LWIP/Target/arch; ../MBEDTLS/App; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include/; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../../../../../../Drivers/CMSIS/RTOS2/Include/; ../../../../../../Middlewares/Third_Party/cJSON; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/Third_Party/mbedTLS/include/; ../../../../../../Middlewares/Third_Party/mbedTLS/include/psa; ../../../../../../Middlewares/Third_Party/mbedTLS/library; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Api; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core; ../../../../../../Middlewares/Third_Party/LwIP/src/include/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/netif/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/netif/ppp/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/priv/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/prot/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/stdc/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/net/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa/; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_at; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_bus
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: configTASK_NOTIFICATION_ARRAY_ENTRIES=8
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ST67W6X_FOTA_LWIP.bin
  prebuild: prebuild.bat
  ILINK.IlinkOutputFile: ST67W6X_FOTA_LWIP.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/User/Appli/App
    ../Appli/App/: fota.c fota_flash.c fota_header.c main_app.c
  group Application/User/Appli/Target
    ../Appli/Target/: freertos_tickless.c logshell_ctrl.c stm32_lpm_if.c
  group Application/User/Core
    ../Core/Src/: app_freertos.c main.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c stm32u5xx_it.c
  group Application/User/LWIP/App
    ../LWIP/App/: altls_mbedtls.c dhcp_server_raw.c http_client.c lwip.c lwip_netif.c sntp.c
  group Application/User/MBEDTLS/App
    ../MBEDTLS/App/: mbedtls.c
  group Application/User/MBEDTLS/Target
    ../MBEDTLS/Target/: hardware_rng.c
  group Application/User/ST67W6X/App
    ../ST67W6X/App/: app_st67w6x.c
  group Application/User/ST67W6X/Target
    ../ST67W6X/Target/: spi_port.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_lptim.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rng.c stm32u5xx_hal_rng_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middlewares/cJSON/Data Exchange/cJSON
    ../../../../../../Middlewares/Third_Party/cJSON/: cJSON.c
  group Middlewares/LwIP/Network/LwIP
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c slipif.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/mbedTLS/Security/mbedTLS
    ../../../../../../Middlewares/Third_Party/mbedTLS/library/: aes.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.c bignum_mod.c bignum_mod_raw.c block_cipher.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecp.c ecp_curves.c ecp_curves_new.c entropy.c entropy_poll.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c nist_kw.c oid.c pem.c pk.c pk_ecc.c pk_wrap.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_rsa.c psa_crypto_se.c psa_crypto_slot_management.c psa_util.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha256.c sha3.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_cookie.c ssl_debug_helpers_generated.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Supported
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/ST67W6X_Network_Driver/Network/ATDriver
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Misc/: common_parser.c
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_at/: modem_cmd_handler.c w61_at_ble.c w61_at_common.c w61_at_mqtt.c w61_at_net.c w61_at_sys.c w61_at_wifi.c
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_bus/: spi_iface.c w61_io.c
  group Middlewares/ST67W6X_Network_Driver/Network/ServiceAPI
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core/: w6x_ble.c w6x_http.c w6x_mqtt.c w6x_net.c w6x_netif.c w6x_sys.c w6x_wifi.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Logging
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Logging/: logging.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
