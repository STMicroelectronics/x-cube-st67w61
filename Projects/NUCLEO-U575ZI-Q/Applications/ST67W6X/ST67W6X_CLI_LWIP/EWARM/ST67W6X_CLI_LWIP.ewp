# IAR project ST67W6X_CLI_LWIP.ewp, settings and files
configuration ST67W6X_CLI_LWIP (ARM, debug)
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: configTASK_NOTIFICATION_ARRAY_ENTRIES=8; ST67_ARCH=W6X_ARCH_T02; LFS_CONFIG=lfs_util_config.h; USE_HAL_DRIVER; STM32U575xx
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../Core/Inc; ../ST67W6X/App; ../Appli/App; ../Appli/Target; ../ST67W6X/Target; ../littlefs/Target; ../LWIP/App; ../LWIP/Target; ../LWIP/Target/arch; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32U5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include/; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../../../../../../Drivers/CMSIS/RTOS2/Include/; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Api; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Shell; ../../../../../../Middlewares/Third_Party/LwIP/src/include/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/netif/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/netif/ppp/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/priv/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/prot/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/stdc/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/net/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa/; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_at; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_bus; ../../../../../../Middlewares/Third_Party/MQTT-C/include; ../../../../../../Middlewares/Third_Party/littlefs
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: configTASK_NOTIFICATION_ARRAY_ENTRIES=8
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ST67W6X_CLI_LWIP.bin
  ILINK.IlinkOutputFile: ST67W6X_CLI_LWIP.out
  ILINK.IlinkIcfFile: stm32u575xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32u575xx.s
  group Application/User/Appli/App
    ../Appli/App/: main_app.c
  group Application/User/Appli/Target
    ../Appli/Target/: freertos_tickless.c logshell_ctrl.c stm32_lpm_if.c
  group Application/User/Core
    ../Core/Src/: app_freertos.c main.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c stm32u5xx_it.c
  group Application/User/littlefs/Target
    ../littlefs/Target/: lfs_easyflash.c lfs_flash.c
  group Application/User/LWIP/App
    ../LWIP/App/: altcp_tls_mbedtls.c dhcp_server_raw.c echo.c lwip.c lwip_netif.c lwip_shell.c ping.c sntp.c
  group Application/User/ST67W6X/App
    ../ST67W6X/App/: app_st67w6x.c
  group Application/User/ST67W6X/Target
    ../ST67W6X/Target/: spi_port.c util_task_port.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../../../../../../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_lptim.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Middlewares/LittleFS/File System/LittleFS
    ../../../../../../Middlewares/Third_Party/littlefs/: lfs.c lfs_util.c
  group Middlewares/LwIP/Network/LwIP
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c slipif.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/MQTT-C/Data Exchange/MQTT-C
    ../../../../../../Middlewares/Third_Party/MQTT-C/src/: mqtt.c mqtt_pal.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Supported
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/ST67W6X_Network_Driver/Network/ATDriver
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Misc/: common_parser.c
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_at/: modem_cmd_handler.c w61_at_ble.c w61_at_common.c w61_at_mqtt.c w61_at_net.c w61_at_sys.c w61_at_wifi.c
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_bus/: spi_iface.c w61_io.c
  group Middlewares/ST67W6X_Network_Driver/Network/ServiceAPI
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core/: w6x_ble.c w6x_http.c w6x_mqtt.c w6x_net.c w6x_netif.c w6x_sys.c w6x_wifi.c
  group Middlewares/ST67W6X_Network_Driver/Network/ServiceShell
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core/: w6x_ble_shell.c w6x_mqtt_shell.c w6x_net_shell.c w6x_sys_shell.c w6x_wifi_shell.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Logging
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Logging/: logging.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Shell
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Shell/: shell.c shell_freertos.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Statistics
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Performance/: iperf.c iperf_shell.c util_mem_perf.c util_task_perf.c wfa_tg.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
