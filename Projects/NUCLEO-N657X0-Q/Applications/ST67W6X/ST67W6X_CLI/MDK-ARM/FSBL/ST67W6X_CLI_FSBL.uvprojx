# Keil uVision project ST67W6X_CLI_FSBL.uvprojx, settings and files
target ST67W6X_CLI_FSBL (6210000::V6.21::ARMCLANG)
  device: STM32N657X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x341C0000-0x341FFFFF) IROM(0x34180400-0x341BFFFF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: ST67W6X_CLI_FSBL +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N657xx,configTASK_NOTIFICATION_ARRAY_ENTRIES=8,ST67_ARCH=W6X_ARCH_T01,LFS_CONFIG=lfs_util_config.h
  c include: ../../FSBL/Core/Inc;../../FSBL/ST67W6X/App;../../FSBL/Appli/App;../../FSBL/Appli/Target;../../FSBL/ST67W6X/Target;../../FSBL/littlefs/Target;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include/;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM55_NTZ/non_secure/;../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/;../../../../../../../Drivers/CMSIS/RTOS2/Include/;../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Api;../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core;../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Api;../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Shell;../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Api;../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_at;../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_bus;../../../../../../../Middlewares/Third_Party/littlefs;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include;../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Include
  asm define: configTASK_NOTIFICATION_ARRAY_ENTRIES=8
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x34180400 size 0x3fc00
  memory RVCT9: RAM 0x341c0000 size 0x40000
  scatter file: stm32n657xx_axisram2_fsbl.sct
  link misc: --keep *.o(FSymTab) --diag_suppress L6319W
  group Application/MDK-ARM
    ../: startup_stm32n657xx_fsbl.c
  group Application/User/FSBL/ST67W6X/App
    ../../FSBL/ST67W6X/App/: app_st67w6x.c
  group Application/User/FSBL/ST67W6X/Target
    ../../FSBL/ST67W6X/Target/: spi_port.c util_task_port.c
  group Application/User/FSBL/Core
    ../../FSBL/Core/Src/: main.c app_freertos.c stm32n6xx_it.c stm32n6xx_hal_msp.c stm32n6xx_hal_timebase_tim.c
  group Application/User/FSBL/Appli/Target
    ../../FSBL/Appli/Target/: logshell_ctrl.c
  group Application/User/FSBL/Appli/App
    ../../FSBL/Appli/App/: main_app.c echo.c fota.c
  group Application/User/FSBL/littlefs/Target
    ../../FSBL/littlefs/Target/: lfs_easyflash.c lfs_flash.c
  group Doc
    ../../: readme.md
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_cortex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_hal_spi.c stm32n6xx_hal_spi_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../../FSBL/Core/Src/: system_stm32n6xx_fsbl.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Secure_Only
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM55_NTZ/non_secure/: port.c portasm.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/ST67W6X_Network_Driver/Network/ServiceAPI
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core/: w6x_ble.c w6x_http.c w6x_mqtt.c w6x_net.c w6x_netif.c w6x_ota.c w6x_sys.c w6x_wifi.c
  group Middlewares/ST67W6X_Network_Driver/Network/ServiceShell
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core/: w6x_ble_shell.c w6x_mqtt_shell.c w6x_net_shell.c w6x_sys_shell.c w6x_wifi_shell.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Logging
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Logging/: logging.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Statistics
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Performance/: iperf.c iperf_shell.c util_mem_perf.c util_task_perf.c wfa_tg.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Shell
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Shell/: shell.c shell_freertos.c
  group Middlewares/ST67W6X_Network_Driver/Network/ATDriver
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_at/: modem_cmd_handler.c w61_at_ble.c w61_at_common.c w61_at_mqtt.c w61_at_net.c w61_at_sys.c w61_at_wifi.c
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_bus/: spi_iface.c w61_io.c
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Misc/: common_parser.c
  group Middlewares/LittleFS/File System/LittleFS
    ../../../../../../../Middlewares/Third_Party/littlefs/: lfs.c lfs_util.c
software components: CMSIS:CORE 5.6.0
