# IAR project ST67W6X_CLI_FSBL.ewp, settings and files
configuration ST67W6X_CLI_FSBL (ARM, debug)
  General.OGChipSelectEditMenu: STM32N657X0 ST STM32N657X0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 63
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32N657xx; configTASK_NOTIFICATION_ARRAY_ENTRIES=8; ST67_ARCH=W6X_ARCH_T01; LFS_CONFIG=lfs_util_config.h
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../../FSBL/Core/Inc; ../../FSBL/ST67W6X/App; ../../FSBL/Appli/App; ../../FSBL/Appli/Target; ../../FSBL/ST67W6X/Target; ../../FSBL/littlefs/Target; ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include/; ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM55_NTZ/non_secure/; ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../../../../../../../Drivers/CMSIS/RTOS2/Include/; ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Api; ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core; ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Api; ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Shell; ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Api; ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_at; ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_bus; ../../../../../../../Middlewares/Third_Party/littlefs; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32N6xx/Include; ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Inc/Legacy; ../../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: configTASK_NOTIFICATION_ARRAY_ENTRIES=8
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ST67W6X_CLI_FSBL.bin
  ILINK.IlinkOutputFile: ST67W6X_CLI_FSBL.out
  ILINK.IlinkIcfFile: stm32n657xx_axisram2_fsbl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32n657xx_fsbl.s
  group Application/User/FSBL/Appli/App
    ../../FSBL/Appli/App/: echo.c fota.c main_app.c
  group Application/User/FSBL/Appli/Target
    ../../FSBL/Appli/Target/: logshell_ctrl.c
  group Application/User/FSBL/Core
    ../../FSBL/Core/Src/: app_freertos.c main.c stm32n6xx_hal_msp.c stm32n6xx_hal_timebase_tim.c stm32n6xx_it.c
  group Application/User/FSBL/littlefs/Target
    ../../FSBL/littlefs/Target/: lfs_easyflash.c lfs_flash.c
  group Application/User/FSBL/ST67W6X/App
    ../../FSBL/ST67W6X/App/: app_st67w6x.c
  group Application/User/FSBL/ST67W6X/Target
    ../../FSBL/ST67W6X/Target/: spi_port.c util_task_port.c
  group Doc
    ../../: readme.md
  group Drivers/CMSIS
    ../../FSBL/Core/Src/: system_stm32n6xx_fsbl.c
  group Drivers/STM32N6xx_HAL_Driver
    ../../../../../../../Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal.c stm32n6xx_hal_cortex.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_exti.c stm32n6xx_hal_gpio.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_spi.c stm32n6xx_hal_spi_ex.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c
  group Middlewares/LittleFS/File System/LittleFS
    ../../../../../../../Middlewares/Third_Party/littlefs/: lfs.c lfs_util.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Secure_Only
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM55_NTZ/non_secure/: port.c portasm.s
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/ST67W6X_Network_Driver/Network/ATDriver
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Misc/: common_parser.c
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_at/: modem_cmd_handler.c w61_at_ble.c w61_at_common.c w61_at_mqtt.c w61_at_net.c w61_at_sys.c w61_at_wifi.c
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_bus/: spi_iface.c w61_io.c
  group Middlewares/ST67W6X_Network_Driver/Network/ServiceAPI
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core/: w6x_ble.c w6x_http.c w6x_mqtt.c w6x_net.c w6x_netif.c w6x_ota.c w6x_sys.c w6x_wifi.c
  group Middlewares/ST67W6X_Network_Driver/Network/ServiceShell
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core/: w6x_ble_shell.c w6x_mqtt_shell.c w6x_net_shell.c w6x_sys_shell.c w6x_wifi_shell.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Logging
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Logging/: logging.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Shell
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Shell/: shell.c shell_freertos.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Statistics
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Performance/: iperf.c iperf_shell.c util_mem_perf.c util_task_perf.c wfa_tg.c
