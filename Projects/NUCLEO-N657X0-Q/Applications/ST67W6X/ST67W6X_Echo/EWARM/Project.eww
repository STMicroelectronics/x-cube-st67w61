<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\FSBL\ST67W6X_Echo_FSBL.ewp</path>
  </project>
  <batchBuild />
</workspace>
