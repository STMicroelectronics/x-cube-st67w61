# IAR project NCP_Loader_Boot.ewp, settings and files
configuration Bootloader (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S3L8 ST STM32H7S3L8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32H7S3xx; NCP_FLASH_MODE
  ICCARM.CCIncludePath2: ../../Boot/Core/Inc; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootloader.bin
  ILINK.IlinkOutputFile: Bootloader.out
  ILINK.IlinkIcfFile: stm32h7s3xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration UART_bypass (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32H7S3xx
  OBJCOPY.OOCOutputFile: UART_bypass.bin
  ILINK.IlinkOutputFile: UART_bypass.out
  group Application/EWARM
    ../: startup_stm32h7s3xx.s
  group Application/User/Boot/Core
    ../../Boot/Core/Src/: main.c stm32h7rsxx_hal_msp.c stm32h7rsxx_it.c
  group Drivers/CMSIS
    ../../Boot/Core/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c
