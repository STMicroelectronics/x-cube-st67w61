# IAR project ST67W6X_CLI_Appli.ewp, settings and files
configuration ST67W6X_CLI_Appli (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7S3L8 ST STM32H7S3L8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7S3xx; configTASK_NOTIFICATION_ARRAY_ENTRIES=8; LFS_CONFIG=lfs_util_config.h
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../../Appli/Core/Inc; ../../Appli/App_CLI/App; ../../Appli/App_CLI/Target; ../../Appli/ST67W6X/Target; ../../Appli/littlefs/Target; ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_at; ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_bus; ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Api; ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core; ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Api; ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Api; ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Shell; ../../../../../../../Middlewares/Third_Party/littlefs; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc; ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy; ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include; ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../../../../../../../Drivers/CMSIS/RTOS2/Include; ../../../../../../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include; ../../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: configTASK_NOTIFICATION_ARRAY_ENTRIES=8
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ST67W6X_CLI_Appli.bin
  ILINK.IlinkOutputFile: ST67W6X_CLI_Appli.out
  ILINK.IlinkIcfFile: stm32h7rsxx_ROMxspi2.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32h7s3xx.s
  group Application/User/Appli/App_CLI/App
    ../../Appli/App_CLI/App/: echo.c fota.c main_app.c
  group Application/User/Appli/App_CLI/Target
    ../../Appli/App_CLI/Target/: logshell_ctrl.c
  group Application/User/Appli/Core
    ../../Appli/Core/Src/: freertos.c main.c stm32h7rsxx_hal_msp.c stm32h7rsxx_hal_timebase_tim.c stm32h7rsxx_it.c
  group Application/User/Appli/littlefs/Target
    ../../Appli/littlefs/Target/: lfs_easyflash.c lfs_flash.c
  group Application/User/Appli/ST67W6X/Target
    ../../Appli/ST67W6X/Target/: spi_port.c
  group Doc
    ../../: readme.md
  group Drivers/CMSIS
    ../../Appli/Core/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../../../../../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_spi.c stm32h7rsxx_hal_spi_ex.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c
  group Middlewares/FreeRTOS
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/Common/: mpu_wrappers.c mpu_wrappers_v2.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/LittleFS/File System/LittleFS
    ../../../../../../../Middlewares/Third_Party/littlefs/: lfs.c lfs_util.c
  group Middlewares/ST67W6X_Network_Driver/Network/Driver/W61_at_and_bus
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Misc/: common_parser.c
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_bus/: spi_iface.c w61_io.c
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_at/: w61_at_ble.c w61_at_common.c w61_at_mqtt.c w61_at_net.c w61_at_rx_parser.c w61_at_sys.c w61_at_wifi.c
  group Middlewares/ST67W6X_Network_Driver/Network/ServiceAPI
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core/: w6x_ble.c w6x_http.c w6x_mqtt.c w6x_net.c w6x_ota.c w6x_sys.c w6x_wifi.c
  group Middlewares/ST67W6X_Network_Driver/Network/ServiceShell
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core/: w6x_ble_shell.c w6x_mqtt_shell.c w6x_net_shell.c w6x_sys_shell.c w6x_wifi_shell.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Logging
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Logging/: logging.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Shell
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Shell/: shell.c shell_freertos.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Statistics
    ../../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Performance/: iperf.c iperf_shell.c util_mem_perf.c util_task_perf.c wfa_tg.c
